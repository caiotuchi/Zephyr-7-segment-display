## build/nucleo_f303re/Kconfig/Kconfig.shield.defconfig
```kconfig
osource "c:\Users\caiog\zephyr-workspace\external\zephyr/boards/shields/*/Kconfig.defconfig"
```
